# Keil uVision project EXTI_Button_1.uvprojx, settings and files
target Target (6190000::V6.19::ARMCLANG)
  device: STM32G031J6Mx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: EXTI_Button
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group tree
    ./: core_cm0_plus_constants.s main.s startup_stm32g031xx.s stm32G0_constants.s
